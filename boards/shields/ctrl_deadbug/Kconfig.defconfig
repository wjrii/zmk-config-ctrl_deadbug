## boards/shields/ctrl_deadbug/Kconfig.defconfig
```kconfig
if SHIELD_CTRL_DEADBUG

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "CTRL Deadbug"

endif
```
